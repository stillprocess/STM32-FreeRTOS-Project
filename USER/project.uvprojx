# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM;..\CMSIS;..\DEVICE_LIB\inc;..\USER;..\FreeRTOS_INCLUDE;..\HARDWARE;..\SYSTEM\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c FreeRTOSConfig.h
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
    ../SYSTEM/: system_stm32f4xx.c
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
  group FreeRTOS_Portable
    ../FreeRTOS_Portable/: port.c portmacro.h
  group FreeRTOS_SOURCE
    ../FreeRTOS_SOURCE/: list.c queue.c tasks.c heap_4.c croutine.c event_groups.c timers.c
  group HARDWARE
    ../HARDWARE/: beep.c beep.h delay.c delay.h dht11.c dht11.h led.c led.h spi1.c spi1.h uart.c uart.h w25q128.c w25q128.h keyboard.c keyboard.h servo.c servo.h oled.c oled.h motor.c motor.h esp8266.c esp8266.h onenet_mqtt.c onenet_mqtt.h FPM383F.c key.c key.h
